# Keil uVision project baseos.uvprojx, settings and files
target baseos (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: baseos +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ..\BSP;..\CORE;..\STM32F1xx_HAL_Driver\Inc;..\STM32F1xx_HAL_Driver\Inc\Legacy;..\USER;..\FreeRTOS_Library\include;..\FreeRTOS_Library\portable\RVDS\ARM_CM3;..\FreeRTOS_Library;..\Util
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group BSP
    ../BSP/: bsp.c bsp_led.c UartCmd.c keyboard.c
  group USER
    ./: main.c stm32f1xx_hal_msp.c stm32f1xx_it.c system_stm32f1xx.c stm32f1xx_hal_conf.h
  group CORE
    ../CORE/: startup_stm32f103xe.s core_cm3.h cmsis_compiler.h cmsis_armclang.h cmsis_armcc.h
    ./: stm32f1xx.h
  group HALLIB
    ../STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_exti.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_uart.c
  group FreeRTOS_CORE
    ../FreeRTOS_Library/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS_Library/portable/MemMang/: heap_4.c
    ../FreeRTOS_Library/portable/RVDS/ARM_CM3/: port.c
  group Utils
    ../Util/: vos.c
